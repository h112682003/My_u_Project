# Keil uVision project ex01.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.7
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: ex01
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c kd1602.c my_i2c.c my_systick.c my_uart.c my_bh1750.c my_timer.c my_max30102_setWR.c my_max30102.c
software components: CMSIS:CORE 4.1.0, Device:Driver:CLK 3.01.000, Device:Driver:GPIO 3.01.000, Device:Driver:SYS 3.01.000, Device:Driver:Timer 3.01.000, Device:Driver:UART 3.01.000, Device:Startup 3.01.000
